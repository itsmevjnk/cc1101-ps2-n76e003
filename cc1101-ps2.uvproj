# Keil uVision project cc1101-ps2.uvproj, settings and files
target N76E003 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: cc1101-ps2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c misc: DEFINE (F_SYS=4000000UL)
  c include: .\hal\include;.\lib\include;.\lib\cc1101
  asm misc: DEFINE (F_SYS=4000000UL)
  group Main code
    ./: main.c main.h STARTUP.A51
  group Libraries
    ./lib/src/: delay.c ps2.c
    ./lib/include/: delay.h ps2.h
  group HAL (libraries for on-chip peripherals)
    ./hal/include/: Function_Define.h N76E003.h SFR_Macro.h timer.h sysclk.h spi.h
    ./hal/src/: timer.c sysclk.c spi.c
  group CC1101 Library
    ./lib/cc1101/: CC1100-CC2500.c CC1100-CC2500.h cc1101.h pins.h TI_CC_CC1100-CC2500.h TI_CC_spi.c TI_CC_spi.h
